# IAR project au1311_rotating.ewp, settings and files
configuration au1311_rotating (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RE ST STM32L476RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\config; ..\libs\freemodbus\modbus\include; ..\libs\freemodbus\modbus\rtu; ..\libs\freemodbus\port; ..\libs\iic_simulate; ..\libs\acc_ref; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: au1311_rotating.bin
  ILINK.IlinkOutputFile: au1311_rotating.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: acc_operation_simu.c au13xx.c main.c mb_command.c mb_functions.c stm32l4xx_it.c
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_usb.c
  group Libs/acc_ref
    ../libs/acc_ref/: bma280.c lsm6dsr.c
  group Libs/iic_sim
    ../libs/iic_simulate/: iic_sim.c
  group Libs/modbus
    ../libs/freemodbus/modbus/: mb.c
    ../libs/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../libs/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../libs/freemodbus/port/: portevent.c portserial.c porttimer.c
